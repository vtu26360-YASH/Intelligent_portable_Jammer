options:
  parameters:
    author: Vel Tech
    description: Autonomous AI-ECM Digital Twin
    generate_options: qt_gui
    id: veltech_autonomous_jammer
    output_language: python
    title: Vel Tech AI-ECM Digital Twin
  states: {}

blocks:
- name: enemy_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,4,1,1
    label: Enemy Signal Offset (Hz)
    start: '-500000'
    step: '10000'
    stop: '500000'
    value: '0'
  states: {}
- name: jammer_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,4,1,2
    label: Jammer Power Output
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: jammer_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,5,1,1
    label: Jammer Targeting (Hz)
    start: '-500000'
    step: '10000'
    stop: '500000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: adder
  id: blocks_add_xx
  parameters:
    comment: Environment Combiner
    type: complex
  states: {}
- name: jammer_display
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"red"'
    comment: Isolated Jammer Feed
    fc: '2400000000'
    fftsize: '1024'
    gui_hint: 0,4,2,2
    name: '"Isolated Jammer Output Generation"'
    type: complex
    ymin: '-100'
  states: {}
- name: jammer_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: Power Control
    const: jammer_amp
    type: complex
  states: {}
- name: jammer_lo
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Jammer Target Tracker
    freq: jammer_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: jammer_lpf
  id: low_pass_filter
  parameters:
    comment: Narrows the Noise
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: jammer_mixer
  id: blocks_multiply_xx
  parameters:
    comment: Shifts Noise
    type: complex
  states: {}
- name: jammer_noise
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Raw Wideband Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: mag_sq
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: power_meter
  id: qtgui_number_sink
  parameters:
    comment: Replaces Progress Bar
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,4,1,2
    label1: Target Power (SNR)
    min: '0'
    name: '"Hardware Signal Intelligence"'
    type: float
  states: {}
- name: spectrum_display
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Main Dashboard
    fc: '2400000000'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,4,4
    name: '"Main SIGINT Environment Monitor"'
    type: complex
    ymin: '-100'
  states: {}
- name: target_signal
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: The Enemy Signal
    freq: enemy_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    comment: API Bridge for Python Brain
    port: '8080'
  states: {}

connections:
- [adder, '0', throttle, '0']
- [jammer_gain, '0', adder, '1']
- [jammer_gain, '0', jammer_display, '0']
- [jammer_lo, '0', jammer_mixer, '1']
- [jammer_lpf, '0', jammer_mixer, '0']
- [jammer_mixer, '0', jammer_gain, '0']
- [jammer_noise, '0', jammer_lpf, '0']
- [mag_sq, '0', power_meter, '0']
- [target_signal, '0', adder, '0']
- [target_signal, '0', mag_sq, '0']
- [throttle, '0', spectrum_display, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
